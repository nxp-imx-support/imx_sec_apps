FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-cryptodev-linux-add-ecdsa-with-caam-secure-key-support.patch"