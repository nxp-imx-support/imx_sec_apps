FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-cryptodev-module-add-ecdsa-with-caam-secure-key.patch"
