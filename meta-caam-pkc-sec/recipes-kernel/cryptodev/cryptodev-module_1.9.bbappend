FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-cryptodev-1.9-Add-ECDSA-with-CAAM-secure-key-support.patch"
